## boards/shields/Sekitei/Kconfig.defconfig
```kconfig
if SHIELD_OnCoroCoro

config ZMK_KEYBOARD_NAME
    default "OnCoroCoro"

endif

config SPI
	default y
```
